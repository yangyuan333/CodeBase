Commit message: update fitSceneSmpl

File: data/urdf/plane0000.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=0000.obj scale=1 1 1; visual mesh filename=0000.obj scale=1 1 1
